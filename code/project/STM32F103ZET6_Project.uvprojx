# Keil uVision project STM32F103ZET6_Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103ZET6_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\libraries\STM32F10x_StdPeriph_Driver\inc;..\libraries\CMSIS;..\libraries\CMSIS\CM3;..\user;..\user\api;..\RT_Thread\inc;..\RT_Thread\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group lib
    ../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cmsis
    ../libraries/CMSIS/CM3/: core_cm3.c
    ../libraries/CMSIS/: system_stm32f10x.c
  group user
    ../user/: main.c stm32f10x_it.c
  group api
    ../user/api/: adc.c beep.c delay.c eeprom_at24c02.c esp8266.c key.c key_interrupt.c led.c modbus.c mqtt.c rs485.c soft_i2c.c spi_flash.c systick.c tim3_ch2_pb5_pwm.c tim6.c usart1.c usart2.c usart3.c
  group RTOS
    ../RT_Thread/port/: board.c context_rvds.S cpuport.c
    ../RT_Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
